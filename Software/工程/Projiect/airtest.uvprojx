# Keil uVision project airtest.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: airtest +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User;..\Handware\Led;..\Handware\DHT11;..\Handware\M26;..\System\delay;..\System\sys;..\System\usart;..\Handware\WDG;..\Handware\OLED;..\Handware\MQ135;..\Handware\KEY;..\Handware\TIME;..\Handware\DS18B20;..\cJSON;..\Handware\JSON
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HANDWARE
    ../Handware/DHT11/: dht11.c
    ../Handware/Led/: led.c
    ../Handware/M26/: M26.c
    ../Handware/WDG/: wdg.c
    ../Handware/OLED/: oled.c
    ../Handware/MQ135/: mq.c
    ../Handware/KEY/: key.c
    ../Handware/TIME/: time.c
    ../Handware/DS18B20/: ds18b20.c
  group USER
    ../User/: main.c stm32f10x_it.c
  group SYSTEM
    ../System/delay/: delay.c
    ../System/usart/: usart.c
    ../System/sys/: sys.c
  group DOC
    ../Doc/: read.txt
